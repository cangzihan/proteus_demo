# Keil uVision project PCF8591_LCD4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PCF8591_LCD4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\system;.\hardware
  group Source Group 1
    ./: main.c
    ./system/: delay.c
    ./hardware/: LCD1602.c I2C.c
